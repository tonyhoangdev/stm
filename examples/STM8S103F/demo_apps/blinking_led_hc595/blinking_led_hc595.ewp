# IAR project blinking_led_hc595.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103F3P
  ICCSTM8.CCIncludePath2: ..\..\..\..\platform\devices; ..\..\..\..\platform\drivers\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: blinking_led_hc595.srec
  ILINK.IlinkOutputFile: blinking_led_hc595.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/: main.c
