# IAR project Project.ewp, settings and files
configuration STM8S103 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..; ..\..\..\..\..\platform\drivers\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8S207 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S207MB STM8S207MB
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8S207
configuration STM8S105 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  ICCSTM8.CCDefines: STM8S105
configuration STM8S003 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  ICCSTM8.CCDefines: STM8S003
configuration STM8S903 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  ICCSTM8.CCDefines: STM8S903
configuration STM8AF52Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF52AA STM8AF52AA
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF52Ax
configuration STM8AF62Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF62AA STM8AF62AA
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF62Ax
configuration STM8AF626x (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6269 STM8AF6269
  ICCSTM8.CCDefines: STM8AF626x
configuration STM8AF622x (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6226 STM8AF6226
  ICCSTM8.CCDefines: STM8AF622x
  group drivers
    ../../../../../platform/drivers/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c
  group User
    ../: main.c stm8s_it.c
